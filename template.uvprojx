# Keil uVision project template.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CH579M WCH
  pack: Keil.WCH57x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x3E800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: __DEBUG,HC32F4A0,USE_DDL_DRIVER
  c misc: --diag_suppress=186,66
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3e800
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --keep=*Handler
