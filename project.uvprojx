# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CH579M WCH
  pack: Keil.WCH57x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x3E800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: HC32L136, __CLK_TCK=RT_TICK_PER_SECOND, USE_DDL_DRIVER, __RTTHREAD__, __DEBUG, RT_USING_ARM_LIBC
  c misc: --diag_suppress=186,66
  c include: applications;.;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\nogcc;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m0;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\dfs\filesystems\romfs;rt-thread\components\finsh;.;rt-thread\include;rt-thread\components\net\lwip-2.0.3\src;rt-thread\components\net\lwip-2.0.3\src\include;rt-thread\components\net\lwip-2.0.3\src\include\ipv4;rt-thread\components\net\lwip-2.0.3\src\arch\include;rt-thread\components\net\lwip-2.0.3\src\include\netif;rt-thread\components\net\lwip-2.0.3\src\include\posix;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\ipc;rt-thread\components\drivers\usb\usbhost;rt-thread\components\drivers\usb\usbhost\class;rt-thread\components\drivers\usb\usbhost\core;rt-thread\components\drivers\usb\usbhost\include;rt-thread\components\drivers\include;rt-thread\components\net\netdev\include;Libraries\CMSIS\Include;Libraries\StdPeriphDriver\inc;.\od_cmds
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3e800
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscalls.c syscall_mem.c libc_syms.c
    rt-thread/components/libc/compilers/common/: stdlib.c time.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c showmem.c div0.c
    rt-thread/libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/rtc/: soft_rtc.c rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/src/: dataqueue.c completion.c workqueue.c pipe.c waitqueue.c ringblk_buf.c ringbuffer.c
  group Drivers
    board/: drv_pin.c drv_eth.c drv_usbh.c drv_uart.c board.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ffunicode.c ff.c
    rt-thread/components/dfs/filesystems/romfs/: romfs.c dfs_romfs.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_file.c cmd.c
  group Kernel
    rt-thread/src/: ipc.c thread.c mempool.c mem.c clock.c object.c irq.c idle.c device.c scheduler.c timer.c kservice.c components.c
  group lwIP
    rt-thread/components/net/lwip-2.0.3/src/api/: netdb.c sockets.c netifapi.c tcpip.c netbuf.c api_lib.c err.c api_msg.c
    rt-thread/components/net/lwip-2.0.3/src/core/: ip.c netif.c sys.c init.c memp.c raw.c tcp_out.c inet_chksum.c stats.c tcp_in.c dns.c timeouts.c udp.c pbuf.c def.c tcp.c
    rt-thread/components/net/lwip-2.0.3/src/core/ipv4/: autoip.c ip4_addr.c dhcp.c etharp.c ip4.c ip4_frag.c icmp.c igmp.c
    rt-thread/components/net/lwip-2.0.3/src/netif/: ethernet.c ethernetif.c lowpan6.c
    rt-thread/components/net/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip-2.0.3/src/arch/: sys_arch.c
  group rt_usbh
    rt-thread/components/drivers/usb/usbhost/core/: hub.c usbhost.c usbhost_core.c driver.c
    rt-thread/components/drivers/usb/usbhost/class/: mass.c udisk.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group StdPeriph
    Libraries/StdPeriphDriver/: CH57x_lcd.c CH57x_pwm.c CH57x_adc.c CH57x_int.c CH57x_uart1.c CH57x_timer1.c CH57x_clk.c CH57x_sys.c CH57x_timer2.c CH57x_uart2.c CH57x_flash.c CH57x_uart0.c CH57x_spi1.c CH57x_timer0.c CH57x_timer3.c CH57x_gpio.c CH57x_pwr.c CH57x_usbdev.c CH57x_spi0.c CH57x_uart3.c
    Libraries/Startup/: startup_ARMCM0.s
