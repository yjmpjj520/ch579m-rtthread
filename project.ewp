# IAR project project.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: RT_USING_DLIBC; USE_DDL_DRIVER; HC32L136; __DEBUG; __RTTHREAD__
  ICCARM.CCIncludePath2: rt-thread\components\libc\compilers\common\nogcc; Libraries\CMSIS\Include; rt-thread\libcpu\arm\common; rt-thread\components\libc\posix\ipc; rt-thread\components\finsh; rt-thread\libcpu\arm\cortex-m0; applications; rt-thread\components\libc\posix\io\poll; rt-thread\components\drivers\include; board; rt-thread\include; Libraries\StdPeriphDriver\inc; .; rt-thread\components\libc\compilers\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM)
  as the first configuration, except:
  General.CoreVariant: 39
  ICCARM.CCDefines: __DEBUG; RT_USING_DLIBC; USE_DDL_DRIVER; HC32L136; __DEBUG; __RTTHREAD__
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/common/: stdlib.c time.c
    rt-thread/components/libc/compilers/dlib/: syscalls.c environ.c syscall_write.c syscall_lseek.c syscall_remove.c syscall_open.c syscall_mem.c syscall_read.c syscall_close.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c showmem.c backtrace.c
    rt-thread/libcpu/arm/cortex-m0/: context_iar.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/src/: ringblk_buf.c ringbuffer.c completion.c pipe.c waitqueue.c workqueue.c dataqueue.c
  group Drivers
    board/: board.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c cmd.c
  group HC32_StdPeriph
    Libraries/Startup/: startup_ARMCM0.s
    Libraries/StdPeriphDriver/: CH57x_timer2.c CH57x_sys.c CH57x_timer3.c CH57x_pwr.c CH57x_int.c CH57x_uart1.c CH57x_timer1.c CH57x_spi1.c CH57x_uart3.c CH57x_timer0.c CH57x_gpio.c CH57x_adc.c CH57x_lcd.c CH57x_usbdev.c CH57x_spi0.c CH57x_usbhostBase.c CH57x_flash.c CH57x_uart2.c CH57x_pwm.c CH57x_usbhostClass.c CH57x_clk.c CH57x_uart0.c
  group Kernel
    rt-thread/src/: timer.c kservice.c irq.c object.c thread.c idle.c mem.c device.c ipc.c scheduler.c clock.c mempool.c components.c
